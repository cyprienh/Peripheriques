# Keil uVision project Voilier.uvprojx, settings and files
target Simulation (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template_Simulation
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;..\SharedDrivers\Include;..\F1_Bordage\Source;..\F2_Orientation_Voilier\Include;..\F4_Transmission\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./Source/: Main.c
  group Drivers
    ../SharedDrivers/Source/: Driver_GPIO.c Driver_ADC.c Driver_UART.c Driver_STD.c Driver_Timer.c
    ../F2_Orientation_Voilier/Source/: Orientation.c
    ../F1_Bordage/Source/: Bordage.c
    ../F4_Transmission/Source/: Transmission.c
target Réel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: Template_Reel
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;..\SharedDrivers\Include;..\F1_Bordage\Source;..\F2_Orientation_Voilier\Include;..\F3_AntiChavirement\Include;..\F4_Transmission\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
